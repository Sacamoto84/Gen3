# Keil uVision project STM32F407_SDIO.uvprojx, settings and files
target STM32F407_SDIO (6240000::V6.24::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F407_SDIO +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,HELIX_CONFIG_FIXEDPOINT,SEGGER
  c include: ../Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;    ../Drivers/CMSIS/Include;    ..\Src\decoders\helix_fixpt\pub;    ..\Src\decoders\helix_fixpt\real;    ..\..\Drivers\SEGGER;    ..\..\Drivers\ILI9341;    ..\..\Drivers\uTFT;    ..\Src\decoders;    ..\Src\helix;    ..\Src\helix\pub;    ..\Src\helix\real;    ..\..\Drivers\Generator;    ..\..\Drivers\INA219;    ..\..\Drivers\uTFT\ILI9341;    ..\..\Drivers\uTFT\ILI9225;    ..\Src\Generator;    ..\..\Drivers\TinyEKF-master\src;    ..\MDK-ARM;    ..\..\Drivers\uTFT\OLED;    ..\SEGGER;    ..\..\Drivers\uTFT\fonts\u8g;    ..\..\Drivers\GyverButton
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1ffff
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ../Src/: main.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
target STM32F407_SDIO_ROM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: STM32F407_SDIO
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;                                                                                                                                                                                                                   ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                                                                                                                                                                                   ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                                                                                                                                                                                   ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                                                                                                                                                                                                   ../Drivers/CMSIS/Include;                                                                                                                                                                                                                   ..\Src\decoders\helix_fixpt\pub;                                                                                                                                                                                                                   ..\Src\decoders\helix_fixpt\real;                                                                                                                                                                                                                   ..\..\Drivers\SEGGER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x186a0
  memory RVCT6: RAM 0x200186a0 size 0x2710
  memory RVCT9: RAM 0x20000000 size 0xffff
  memory RVCT10: RAM 0x2001c000 size 0x4000
target RAM_FULL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: STM32F407_SDIO
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,VECT_TAB_SRAM,SEGGER,HELIX_CONFIG_FIXEDPOINT,ILI9225
  c include: ../Inc;                                                                                                                                         ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                                                                                                         ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                                                                                                         ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                                                                                                                         ../Drivers/CMSIS/Include;                                                                                                                                         ..\Src\decoders\helix_fixpt\pub;                                                                                                                                         ..\Src\decoders\helix_fixpt\real;                                                                                                                                         ..\..\Drivers\SEGGER;                                                                                                                                         ..\..\Drivers\ILI9341;                                                                                                                                         ..\..\Drivers\uTFT;                                                                                                                                         ..\Src\decoders;                                                                                                                                         ..\Src\helix;                                                                                                                                         ..\Src\helix\pub;                                                                                                                                         ..\Src\helix\real;                                                                                                                                         ..\..\Drivers\Generator;                                                                                                                                         ..\..\Drivers\INA219;                                                                                                                                         ..\..\Drivers\uTFT\ILI9341;                                                                                                                                         ..\..\Drivers\uTFT\ILI9225;                                                                                                                         ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                                                                                                                  ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;                                                                                                       ../Middlewares/Third_Party/FatFs/src
  memory RVCT1: ROM 0x10000000 size 0xffff
  memory RVCT4: ROM 0x20000000 size 0x7ff
  memory RVCT9: RAM 0x20000800 size 0x1b800
  memory RVCT10: RAM 0x2001c000 size 0x4000
software components: CMSIS:CORE 6.2.0
